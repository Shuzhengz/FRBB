# Keil uVision project FRBB.uvprojx, settings and files
target Target 1 (6140000::V6.14::ARMCLANG)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: FRBB
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group SYSTEM
    ./SYSTEM/sys/: sys.c sys.h stm32f10x.h core_cm3.h system_stm32f10x.h
    ./SYSTEM/delay/: delay.c delay.h
    ./SYSTEM/usart/: usart.c usart.h
  group USER
    ./USER/: test.cpp
